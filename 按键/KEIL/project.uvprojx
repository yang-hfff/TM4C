# Keil uVision project project.uvprojx, settings and files
target Target 1 (5030076::V5.03 [Build 76]::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bin --output ./Objects/project.bin ./Objects/project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: ..\USER;..\LIB;..\BSP;..\APP\MultiButton
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../APP/MultiButton/: multi_button.c
  group BSP
    ../BSP/: serial.c system.c tick.c key.c
  group USER
    ../USER/: main.c
  group LIB
    ../LIB/driverlib/: adc.c can.c comp.c cpu.c eeprom.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
